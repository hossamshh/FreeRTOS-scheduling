# Keil uVision project project1_01.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project1_01
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Downloads\tiva-c-master\tiva-c-master
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: tm4c123gh6pm.h main.c uartstdio.c
  group Tivaware
    ../../../Downloads/tiva-c-master/tiva-c-master/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.2.1, RTOS:Core 10.2.1, RTOS:Heap 10.2.1, RTOS:Stream Buffer 10.2.1, RTOS:Timers 10.2.1, CMSIS:CORE 5.3.0, Device:Startup 1.0.1
